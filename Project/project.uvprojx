# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\User;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\HARDWARE\ADC;..\HARDWARE\RS485;..\HARDWARE\RSCG12864B;..\HARDWARE\IO;..\Application\DISPLAY;..\Application\CMD;..\Application\FUNN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h config.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/RSCG12864B/: RSCG12864B.c
    ../HARDWARE/IO/: IO.c
  group Application
    ../Application/DISPLAY/: display.c
    ../Application/CMD/: cmd.c
    ../Application/FUNN/: funn.c
  group Doc
    ../Doc/: readme.txt process.txt
